# Keil uVision project GUIForAudio.uvprojx, settings and files
target Pro (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GUIForAudio +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD,
  c misc: --gnu
  c include: ..\inc;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\..\Utilities\lvgl;..\..\..\Utilities\lvgl\lvgl;..\..\..\Utilities\lvgl\lvgl\lv_core;..\..\..\Utilities\lvgl\lvgl\lv_draw;..\..\..\Utilities\lvgl\lvgl\lv_hal;..\..\..\Utilities\lvgl\lvgl\lv_misc;..\..\..\Utilities\lvgl\lvgl\lv_misc\lv_fonts;..\..\..\Utilities\lvgl\lvgl\lv_objx;..\..\..\Utilities\lvgl\lvgl\lv_themes;..\..\..\Utilities\lvgl\lvgl\lv_hal
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group StartUp
    ./: startup_stm32f10x_md.s
  group App
    ../src/: system_stm32f10x.c main.c user_api.c user_init.c adc_ctrl.c app_port.c buzzer.c code_switch.c common.c flash_ctrl.c io_buf_ctrl.c IOCtrl.c key_led.c key_led_ctrl.c key_led_table.c message.c message_2.c protocol.c extern_peripheral.c message_3.c logo.c screen_protect.c message_usb.c
  group gui
    ../src/: demo.c gui_driver.c lv_font_chs_24.c gui.c gt9147.c gt811.c I2C.c lcd.c
  group C2D
    ../src/: C2D.c GUI_DrawLine.c GUI_DrawPoint.c GUI_DrawPolygon.c GUI_DrawPolyline.c GUI_FillPolygon.c GUI_FillRect.c GUI2DLib.c GUICirc.c
  group CMSIS
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group lv_core
    ../../../Utilities/lvgl/lvgl/lv_core/: lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c lv_vdb.c
  group lv_draw
    ../../../Utilities/lvgl/lvgl/lv_draw/: lv_draw.c lv_draw_rbasic.c lv_draw_vbasic.c
  group lv_hal
    ../../../Utilities/lvgl/lvgl/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lv_mise
    ../../../Utilities/lvgl/lvgl/lv_misc/: lv_anim.c lv_area.c lv_circ.c lv_color.c lv_font.c lv_fs.c lv_ll.c lv_mem.c lv_task.c lv_templ.c lv_trigo.c lv_txt.c lv_ufs.c lv_math.c
  group lv_objx
    ../../../Utilities/lvgl/lvgl/lv_objx/: lv_bar.c lv_btn.c lv_btnm.c lv_cb.c lv_chart.c lv_cont.c lv_ddlist.c lv_gauge.c lv_img.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_roller.c lv_slider.c lv_sw.c lv_ta.c lv_tabview.c lv_win.c
  group lv_themes
    ../../../Utilities/lvgl/lvgl/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c
  group lv_fonts
    ../../../Utilities/lvgl/lvgl/lv_misc/lv_fonts/: lv_font_dejavu_10.c lv_font_dejavu_10_cyrillic.c lv_font_dejavu_10_latin_sup.c lv_font_dejavu_20.c lv_font_dejavu_20_cyrillic.c lv_font_dejavu_20_latin_sup.c lv_font_dejavu_30.c lv_font_dejavu_30_cyrillic.c lv_font_dejavu_30_latin_sup.c lv_font_dejavu_40.c lv_font_dejavu_40_cyrillic.c lv_font_dejavu_40_latin_sup.c lv_font_symbol_10.c lv_font_symbol_20.c lv_font_symbol_30.c lv_font_symbol_40.c
  group USB_Config
    ../src/: usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c hw_config.c
  group USB_Driver
    ../../../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
software components: CMSIS:CORE 4.3.0
